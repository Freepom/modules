# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: main +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\SRC
  group Source Group 1
    ./: STARTUP.A51 main.c Readkey_lib_A01.LIB
    ./SRC/: DispDrv.c AT24C.C DS1302.c
