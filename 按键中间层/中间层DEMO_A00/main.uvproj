# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Readkey_lib_A00 +hex (library)
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Objects
  group Source Group 1
    ./: STARTUP.A51 ReadKey.c
